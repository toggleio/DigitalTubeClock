# Keil uVision project Light_up_an_LED.uvproj, settings and files
target Target (MCS-51)
  device: STC15W408AS Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: Clock +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Inc
  group New Group
    ./: main.c
